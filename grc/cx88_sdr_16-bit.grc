options:
  parameters:
    generate_options: qt_gui
    id: cx88_sdr_16bit
    output_language: python
    title: cx88_sdr 16-bit
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gr-fifo0
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/swradio0
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
